# Keil uVision project PJMainControlMCU.uvprojx, settings and files
target debug (ARM-ADS)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: PJMainControlMCU +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=output\debug\@L.bin !L
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,FW_DEBUG
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Inc;..\LWIP\arch;..\LWIP\lwip_app\lwip_comm;..\LWIP\lwip_app\tcp_demo;..\LWIP\lwip_app\udp_demo;..\LWIP\lwip-1.4.1\src\include;..\LWIP\lwip-1.4.1\src\include\ipv4;..\LWIP\lwip-1.4.1\src\include\netif;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4x7_ETH_Driver\inc;..\MALLOC;..\logger;..\Warp\Inc;..\it6635;..\it6635\chip;..\it6635\customer;..\it6635\chip\cec;..\STMFlash;..\ModeCtl
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_spi.c stm32f4xx_hal_iwdg.c
  group Driver/STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c
  group Driver/STM32F4x7_ETH_Driver
    ../Libraries/STM32F4x7_ETH_Driver/src/: stm32f4x7_eth.c
  group Startup
    ../Startup/: startup_stm32f407xx.s
  group User/src/func
    ../User/src/funs/src/: adc.c cmd_process.c dma.c error.c gpio.c healthMgr.c i2c.c main.c md5.c Motor.c pjlink.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c tim.c usart.c fanctl.c modectl.c delay3D.c power_monitor.c
  group User/src/utils
    ../User/src/utils/src/: logger.c util.c malloc.c ezxml.c base64.c
  group User/src/drivers
    ../User/src/drivers/src/: lan8720.c stmflash.c AD5241.c
  group User/src/modules
    ../User/src/modules/src/: rt_param.c iap.c
  group User/src/libs/c381
    ../User/src/libs/c381/: c381.c calc_linecoef.c calc_pjconv.c change_board.c check_wplimit.c conv_char_int.c egb_bias.c egb_bias_areawr.c egb_bias_gamma.c egb_gain.c egb_gamma.c init_C381.c init_wptable.c move_cur.c output_gamma.c sel_cur.c set.c set_color_convergence.c set_lut_wp.c set_ofill.c set_split_wp.c set_uniformity.c st.c test_pattern.c update_input.c wait_pivs.c wait_povs.c warp.c warp_mode.c write_wptable.c
  group User/src/libs/lwip_arch
    ../User/src/libs/LWIP/arch/: sys_arch.c
  group User/src/libs/lwip_app
    ../User/src/libs/LWIP/lwip_app/lwip_comm/: lwip_comm.c
    ../User/src/libs/LWIP/lwip_app/tcp_demo/: tcp_demo.c
    ../User/src/libs/LWIP/lwip_app/udp_demo/: udp_demo.c
  group User/src/libs/lwip_netif
    ../User/src/libs/LWIP/lwip-1.4.1/src/netif/: etharp.c ethernetif.c
  group User/src/libs/lwip_core
    ../User/src/libs/LWIP/lwip-1.4.1/src/core/ipv4/: autoip.c icmp.c igmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c
    ../User/src/libs/LWIP/lwip-1.4.1/src/core/: def.c dhcp.c dns.c init.c mem.c memp.c netif.c pbuf.c raw.c stats.c tcp.c tcp_in.c tcp_out.c timers.c udp.c
  group User/src/libs/lwip_api
    ../User/src/libs/LWIP/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
  group User/src/libs/it6635
    ../User/src/libs/it6635/chip/: it6635.c it6635_cec.c it6635_eq.c it6635_opts.c platform inf.c
    ../User/src/libs/it6635/customer/: it6635_cecsys.c
  group User/src/hal
    ../User/src/hal/: netRpcCall.c uart_protocal.c
  group User/src/svc
    ../User/src/svc/: uartCmdProc.c
  group User/src/libs/cJSON
    ../User/src/libs/cJSON/: cJSON.c cJSON_test.c cJSON_Utils.c
target release (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: as above
  output: PJMainControlMCU +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=output\release\@L.bin !L
  c flags: Optim=4 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING,ARM_MATH_CM4,__CC_ARM,FW_RELEASE
  c misc: --diag_suppress 550
  c include: ../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\Libraries\STM32F4x7_ETH_Driver\inc;..\User\src\funs\inc;..\User\src\utils\inc;..\User\src\drivers\inc;..\User\src\modules\inc;..\User\src\libs\c381\Inc;..\User\src\libs\LWIP\arch;..\User\src\libs\LWIP\lwip_app\lwip_comm;..\User\src\libs\LWIP\lwip_app\tcp_demo;..\User\src\libs\LWIP\lwip_app\udp_demo;..\User\src\libs\LWIP\lwip-1.4.1\src\include;..\User\src\libs\LWIP\lwip-1.4.1\src\include\ipv4;..\User\src\libs\LWIP\lwip-1.4.1\src\include\netif;..\User\src\libs\it6635;..\User\src\libs\it6635\chip;..\User\src\libs\it6635\customer;..\User\src\libs\it6635\chip\cec;..\User\src\hal;..\User\src\svc;..\User\src;..\User\src\utils\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x70000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:CORE 6.1.0
